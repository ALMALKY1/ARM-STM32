# Keil uVision project ARM.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Common
    ./: STD_TYPES.h BIT_OP.h
  group MCAL
    ./: RCC_Program.c RCC_Interface.h RCC_Private.h RCC_Config.h GPIO_Program.c GPIO_Config.h GPIO_Private.h GPIO_Interface.h NVIC_Program.c NVIC_Config.h NVIC_Interface.h NVIC_Private.h EXTI_Program.c EXTI_Private.h EXTI_Interface.h EXTI_Config.h SYSTICK_Program.c SYSTICK_Private.h SYSTICK_Config.h SYSTICK_Interface.h DMA_Program.c DMA_Interface.h DMA_Private.h DMA_Config.h
  group HAL
    ./: DOTMATRIX_Program.c DOTMATRIX_private.h DOTMATRIX_interface.h DOTMATRIX_config.h
  group APP
    ./: main.c main_1.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
